# Keil uVision project stm32f205rc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DAPLINK_VERSION=254, MSC_ENDPOINT, DAPLINK_BL, DAPLINK_BUILD_KEY=0x9B939D93, DRAG_N_DROP_SUPPORT, OS_TICK=10000, INTERFACE_STM32F205XC, USE_HAL_DRIVER, STM32F205xx, DAPLINK_HIC_ID=0x97969922, __packed=__packed, DAPLINK_NO_ASSERT_FILENAMES, OS_CLOCK=72000000
  c include: ..\..\..\usb;..\..\..\daplink;..\..\..\daplink\bootloader;..\..\..\hic_hal;..\..\..\daplink\drag-n-drop;..\..\..\daplink\settings;..\..\..\target;..\..\..\rtos_none;..\..\..\hic_hal\stm32\stm32f205xC;..\..\..\hic_hal\stm32\stm32f205xC\cmsis;..\..\..\hic_hal\stm32\stm32f205xC\STM32F2xx_HAL_Driver;..\..\..\hic_hal\stm32\stm32f205xC\STM32F2xx_HAL_Driver\Inc;..\..\..\cmsis-core
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DMSC_ENDPOINT,-DDAPLINK_BL,-DDAPLINK_BUILD_KEY=0x9B939D93,-DDRAG_N_DROP_SUPPORT,-DOS_TICK=10000,-DINTERFACE_STM32F205XB,-DUSE_HAL_DRIVER,-DSTM32F205xc,-DDAPLINK_HIC_ID=0x97969908,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=72000000 --no_unaligned_access
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_BL" --predefine="-I..\..\..\hic_hal\stm32\stm32f205xC"
  group board
    ../../../board/: stm32f205xc_bl.c
  group daplink_bl
    ../../../daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
    ../../../daplink/bootloader/: daplink.c main.c
    ../../../daplink/interface/: SVC_Table.s
  group drag-n-drop
    ../../../daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group hic_hal
    ../../../hic_hal/stm32/stm32f205xC/: flash.c gpio.c read_uid.c sdk.c uart.c usb_config.c usbd_STM32F205.c
    ../../../hic_hal/stm32/stm32f205xC/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rng.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
    ../../../hic_hal/stm32/stm32f205xC/cmsis/: system_stm32f2xx.c
    ../../../hic_hal/stm32/stm32f205xC/armcc/: startup_stm32f205xx.s
    ../../../hic_hal/stm32/stm32f205xc/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_ll_usb.c
  group rtos
    ../../../rtos_none/: cmsis_os2_port.c SysTick_Handler.c
  group settings
    ../../../daplink/settings/: settings.c settings_rom_stub.c
  group target
    ../../../target/: target_board.c
  group usb
    ../../../usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../usb/: usbd_core.c
